# Keil uVision project HT52352_Project.uvprojx, settings and files
target HT32F52352 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HT32F52352 Holtek
  pack: Holtek.HT32_DFP.1.0.25
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x1FE00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HT52352_Project +hex
  AfterMake: fromelf --bin -o #L.bin #L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52352
  c include: ..\Libraries\CMSIS\Include;..\Libraries\Device\Holtek\HT32F5xxxx\Include;..\Libraries\HT32F5xxxx_Driver\inc;..\Libraries\HT32_USBD_Library\inc;..\Source\Utilities;..\Source\Dev;..\Source\Main;..\Source\Dev\Ov7725;..\Source\Dev\Malloc;..\Source\Dev\SPI_SD_Card;..\Source\Dev\Fatfs\src;..\Source\Dev\Fatfs\src\option;..\Source\Dev\Picture;..\Source\Dev\Fatfs\exfuns;..\Source\Packages\MultiTimer-master;..\Source\App;..\Source\Packages\RingBuffer;..\Source\Dev\HMAC\inc;..\Source\device;..\Source\Dev;..\Source\Dev
  asm define: USE_HT32_CHIP=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group User
    ../Source/Main/: main.c ht32f5xxxx_01_it.c
    ../Source/Dev/: config.h
  group Startup
    ../Source/Main/: startup_ht32f5xxxx_01.s
  group CMSIS
    ../Source/Main/: system_ht32f5xxxx_01.c
  group Config
    ../Source/Main/: ht32f5xxxx_01_usbdconf.h ht32f5xxxx_conf.h ht32_op.s HT32F5xxxx_01_DebugSupport.ini
  group FwLib
    ../Libraries/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c ht32_serial.c ht32_retarget.c
  group Bsp
    ../Source/Dev/: system.c bsp_BFTM.c bsp_i2c.c bsp_spi.c bsp_SysTick.c bsp_uart1.c bsp_usart0.c bsp_MCTM.c bsp_pwm.c bsp_GPTM.c bsp_wifi.c mqtt.c
  group Packages
    ../Source/Packages/MultiTimer-master/: multi_timer.c
    ../Source/Packages/RingBuffer/: ringbuffer.c
  group App
    ../Source/App/: task.c
  group Utilities
    ../Source/Utilities/: ht32_board.c
  group Doc
    ../: Readme.txt
  group HMAC
    ../Source/Dev/HMAC/scr/: utils_hmac.c utils_md5.c utils_sha1.c
  group Dev
    ../Source/device/: UART0.c UART0.h
    ../Source/Dev/: USART1.c USART1.h source.c source.h iic.c iic.h INA226_IIC.c INA226_IIC.h INA226.c INA226.h MySPI.c MySPI.h W25Q64.c W25Q64.h
